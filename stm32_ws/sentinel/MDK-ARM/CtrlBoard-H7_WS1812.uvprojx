# Keil uVision project CtrlBoard-H7_WS1812.uvprojx, settings and files
target CtrlBoard-H7_WS1812 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CtrlBoard-H7_WS1812 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY
  c misc: --wchar32 --enum_is_int
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../User/APP;../User/APP_Support;../User/APP_Support/common;../User/APP_Support/gimbal;../User/APP_Support/chassis;../User/APP_Support/shoot;../User/APP_Support/power_control;../User/BSP;../User/Devices;../User/Algorithm;../User/Algorithm/Include;../User/Communication/core;../User/Communication/channel/gimbal;../User/Communication/channel/camera;../User/Communication/channel/time_sync;../User/Communication/example/device;../User/Communication/example/shared;../User/Communication/legacy;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c octospi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group APP
    ../User/APP/: Safewarning.c auto_aim.c gimbal_task.c service_task.c light_task.c chassis_task.c detect_task.c referee_usart_task.c referee_usart_task.h
  group APP_Support/common
    ../User/APP_Support/common/: robot_param.h protocol.h referee.c referee.h struct_typedef.h flash_log.c flash_log.h
  group APP_Support/chassis
    ../User/APP_Support/chassis/: chassis_behaviour.c chassis_behaviour.h chassis_calculate.c chassis_calculate.h Omni_chassis.c Omni_chassis.h
  group APP_Support/power_control
    ../User/APP_Support/power_control/: chassis_power_control.c chassis_power_control.h pm01_api.c pm01_api.h wattmeter_api.c wattmeter_api.h
  group APP_Support/gimbal
    ../User/APP_Support/gimbal/: gimbal_behaviour.c gimbal_behaviour.h target_curve.c target_curve.h yaw_pitch_direct.c yaw_pitch_direct.h
  group APP_Support/shoot
    ../User/APP_Support/shoot/: shoot_task.c shoot_task.h shoot.c shoot.h
  group Communication
    ../User/Communication/core/: comm.c uproto.c
    ../User/Communication/example/device/: platform_stm32.c comm_app.c usb_cdc_port.c
    ../User/Communication/channel/gimbal/: gimbal_channel.c
    ../User/Communication/channel/camera/: camera_channel.c
    ../User/Communication/channel/time_sync/: time_sync_channel.c
    ../User/Communication/legacy/: legacy_proto.c legacy_bridge.c
  group BSP
    ../User/BSP/: bsp_fdcan.c bsp_usart.c fifo.c fifo.h remote_control.c bsp_tim24.c
  group Devices
    ../User/Devices/: vofa.c ws2812.c hwt_imu.c w25q64.c
  group Algorithm
    ../User/Algorithm/: adrc.c adrc.h CRC8_CRC16.c CRC8_CRC16.h gravity_comp.c gravity_comp.h pid.c pid.h user_lib.c user_lib.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.0
