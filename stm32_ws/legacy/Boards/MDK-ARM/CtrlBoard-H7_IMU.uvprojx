# Keil uVision project CtrlBoard-H7_IMU.uvprojx, settings and files
target CtrlBoard-H7_IMU (6210000::V6.21::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CtrlBoard-H7_IMU +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\..\ThirdParty\CMSIS-DSP\Include;..\..\ThirdParty\CMSIS-DSP\PrivateInclude;..\..\Bsp;..\..\Bsp\Src;..\..\Robot;..\..\Robot\Infantry;..\..\Robot\Test;..\..\Devices;..\..\Devices\Src;..\..\Algorithm;..\..\Algorithm\Src;..\..\Component\Observer;..\..\Component\Observer\Src;..\..\Component\Aim;..\..\Component\Debug;..\..\Component\Debug\Src;..\..\Component\Communication;..\..\Component\Communication\Src;..\..\Component\Communication\Src\Generate;..\..\Component\Controller\Power;..\..\Component\Controller\Chassis;..\..\Component\Controller\Chassis\Src;..\..\Component\Controller\Gimbal;..\..\Component\Controller\Gimbal\Src;..\..\Component\Controller\Shoot;..\..\Component\Controller\Shoot\Src;..\..\Component\Controller\Thermal;..\..\Component\Input;..\..\Component\Input\Src;..\..\Component\Ui;..\..\Component\Ui\Src;..\..\Apps;..\..\Tasks;..\..\Tasks\Src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Boards/ST
    ./: startup_stm32h723xx.s
  group Boards/ST/Core
    ../Core/Src/: gpio.c adc.c crc.c dma.c dts.c fdcan.c octospi.c rng.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Boards/ST/HAL
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dts.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ospi.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Boards/ST/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Tasks
    ../../Tasks/: main.c
    ../../Tasks/Src/: task_main.c
  group Apps
    ../../Apps/: app_board_test.c app_communication.c app_board_link.c app_calibration.c app_observe.c app_input.c app_magazine.c app_gimbal.c app_chassis.c app_shoot.c app_referee.c app_daemon.c app_alarm.c
  group Bsp
    ../../Bsp/: bsp.c
    ../../Bsp/Src/: bsp_adc.c bsp_crc.c bsp_dts.c bsp_dwt.c bsp_fdcan.c bsp_gpio.c bsp_ospi.c bsp_rng.c bsp_spi.c bsp_tim.c bsp_timebase.c bsp_uart.c bsp_cdc.c bsp_usb.c
  group Algorithm
    ../../Algorithm/Src/: common.c pid_core.c pid_linear.c pid_angle.c pid.c kalman.c extended_kalman.c mahony.c ballistic.c
  group ThirdParty/CMSIS-DSP
    ../../ThirdParty/CMSIS-DSP/Source/CommonTables/: arm_common_tables.c
    ../../ThirdParty/CMSIS-DSP/Source/FastMathFunctions/: arm_sin_f32.c arm_cos_f32.c
    ../../ThirdParty/CMSIS-DSP/Source/MatrixFunctions/: arm_mat_init_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mat_inverse_f32.c
  group Robot
    ../../Robot/: robot.h robot_id.h robot_board.h robot_board_map.h
    ../../Robot/Infantry/: infantry_steer_2025.h infantry_steer_2025_map.h infantry_steer_2025_param.h
    ../../Robot/Test/: board_only_dm02.h board_only_dm02_map.h board_only_dm02_param.h
  group Component/Observer
    ../../Component/Observer/: observer.c
    ../../Component/Observer/Src/: observer_common.c observer_ins.c observer_chassis.c observer_balance.c
    ../../Component/Controller/Thermal/: thermal.c
  group Component/Aim
    ../../Component/Aim/: aim.c
  group Component/Controller/Gimbal
    ../../Component/Controller/Gimbal/: gimbal.c
    ../../Component/Controller/Gimbal/Src/: gimbal_direct_yaw_pitch.c gimbal_double_yaw_pitch.c gimbal_linkage_yaw_pitch.c
  group Component/Controller/Power
    ../../Component/Controller/Power/: power_ctrl.c
  group Component/Controller/Chassis
    ../../Component/Controller/Chassis/: chassis.c
    ../../Component/Controller/Chassis/Src/: chassis_mecanum.c chassis_omni.c chassis_steering.c chassis_balance.c
  group Component/Controller/Shoot
    ../../Component/Controller/Shoot/: shoot.c
    ../../Component/Controller/Shoot/Src/: shoot_none.c shoot_mono.c shoot_double.c
  group Component/Input
    ../../Component/Input/: input.c
    ../../Component/Input/Src/: input_common.c input_gimbal_rc.c input_gimbal_vision.c input_gimbal_planner.c input_chassis_rc.c input_chassis_slam.c input_chassis_planner.c input_cali_rc.c input_shoot_rc.c input_shoot_planner.c
  group Component/Debug
    ../../Component/Debug/: debug.c
    ../../Component/Debug/Src/: debug_log.c debug_platform_stm32.c debug_probe.c debug_profiler.c
  group Component/Communication
    ../../Component/Communication/: communication.c
    ../../Component/Communication/Src/: communication_debug.c communication_board.c communication_host.c communication_time.c communication_vofa.c
    ../../Component/Communication/Src/Generate/: proto2_rt.c
  group Component/Ui
    ../../Component/Ui/: ui.c
    ../../Component/Ui/Src/: ui_common.c ui_referee.c ui_hud_g.c
  group Devices
    ../../Devices/Src/: buzzer.c magazine.c motor.c imu.c imu_heat.c imu_bmi088.c flash.c flash_w25q64.c motor_dji.c motor_dm.c motor_mit.c motor_rs.c tfmini.c rc.c rc_dbus.c rc_sbus.c referee_protocol.c referee.c power.c ws2812.c
  group Boards/RTOS/FreeRTOS
    ../Core/Src/: freertos.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
  group Boards/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
    ../USB_DEVICE/Target/: usbd_conf.c
  group Boards/USB_DEVICE/Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
